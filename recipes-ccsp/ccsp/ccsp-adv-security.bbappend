require ccsp_common_filogic.inc
