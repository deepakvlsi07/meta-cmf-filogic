FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://rp-filogic.patch"

