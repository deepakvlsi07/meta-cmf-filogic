RDEPENDS_packagegroup-rdk-oss-broadband_remove = "alljoyn"
RDEPENDS_packagegroup-rdk-oss-broadband_remove = " zilker-sdk"
