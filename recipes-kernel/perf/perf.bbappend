RDEPENDS_${PN}_remove = "elfutils" 